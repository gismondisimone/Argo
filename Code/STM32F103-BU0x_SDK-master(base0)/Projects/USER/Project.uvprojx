# Keil uVision project Project.uvprojx, settings and files
target Project (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=3 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ../USER;../LIB/inc;../CMSIS;../../Components/HAL;../../Components/APP;../../Components/HAL/USB/src;../../Components/HAL/USB/lib;../../Components/HAL/DW/decadriver;../../Components/Main;../../Components/HAL/OLED;..\..\Components\HAL\LIS2DH12;..\..\Components\HAL\HAL;..\..\Components\HAL\DW\twr_pdoa\inc;..\..\Components\HAL\DW\twr_pdoa\lib;..\..\Components\Examples\examples\ex_00a_reading_dev_id;..\..\Components\Examples\examples\ex_01a_simple_tx;..\..\Components\Examples\examples\ex_01d_tx_timed_sleep;..\..\Components\Examples\examples\ex_01h_simple_tx_pdoa;..\..\Components\Examples\examples\ex_02a_simple_rx;..\..\Components\Examples\examples\ex_02h_simple_rx_pdoa;..\..\Components\Examples\examples\ex_03a_tx_wait_resp;..\..\Components\Examples\examples\ex_03b_rx_send_resp;..\..\Components\Examples\examples\ex_03d_tx_wait_resp_interrupts;..\..\Components\Examples\examples\examples_info;..\..\Components\Examples\examples\ex_05c_ds_twr_init_sts_sdc;..\..\Components\Examples\examples\ex_05d_ds_twr_resp_sts_sdc;..\..\..\..\..\..\..\..\AppData\Local\Keil_v5\ARM\ARMCC\include;..\USER
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../../Components/APP/: cmd.c cmd_fn.c Generic.c Generic_cmd.c user_out.c user_out.h
    ./RTE/Device/STM32F103C8/: startup_stm32f10x_md.s system_stm32f10x.c
  group HAL
    ../../Components/HAL/HAL/: hal_drivers.c hal_flash.c hal_iic.c hal_led.c hal_spi.c hal_timer.c hal_usart.c hal_usb.c
  group DW/Driver
    ../../Components/HAL/DW/decadriver/: deca_device.c deca_mutex.c
  group OLED
    ../../Components/HAL/OLED/: OLED_I2C.c
  group USB
    ../../Components/HAL/USB/src/: hw_config.c Queue.c usb_desc.c usb_endp.c usb_istr.c usb_it.c usb_prop.c usb_pwr.c
    ../../Components/HAL/USB/lib/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group LIS2DH12
    ../../Components/HAL/LIS2DH12/: lis2dh12.c
  group TWR_PDOA/Lib
    ../../Components/HAL/DW/twr_pdoa/lib/: aitcmd.lib os.lib pdoa.lib twr.lib
  group Main
    ../../Components/Main/: main.c stm32f10x_it.c
  group Example
    ../../Components/Examples/examples/ex_01a_simple_tx/: simple_tx.c
software components: Device:StdPeriph Drivers:ADC 3.6.0, Device:StdPeriph Drivers:BKP 3.6.0, Device:StdPeriph Drivers:CAN 3.6.0, Device:StdPeriph Drivers:CEC 3.6.0, Device:StdPeriph Drivers:CRC 3.6.0, Device:StdPeriph Drivers:DAC 3.6.0, Device:StdPeriph Drivers:DBGMCU 3.6.0, Device:StdPeriph Drivers:DMA 3.6.0, Device:StdPeriph Drivers:EXTI 3.6.0, Device:StdPeriph Drivers:FSMC 3.6.0, Device:StdPeriph Drivers:Flash 3.6.0, Device:StdPeriph Drivers:Framework 3.6.0, Device:StdPeriph Drivers:GPIO 3.6.0, Device:StdPeriph Drivers:I2C 3.6.0, Device:StdPeriph Drivers:IWDG 3.6.0, Device:StdPeriph Drivers:PWR 3.6.0, Device:StdPeriph Drivers:RCC 3.6.0, Device:StdPeriph Drivers:RTC 3.6.0, Device:StdPeriph Drivers:SDIO 3.6.0, Device:StdPeriph Drivers:SPI 3.6.0, Device:StdPeriph Drivers:TIM 3.6.0, Device:StdPeriph Drivers:USART 3.6.0, Device:StdPeriph Drivers:WWDG 3.6.0
